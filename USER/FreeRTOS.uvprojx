# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\HARDWARE\ETHERNET;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\HARDWARE\SRAM;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/ETHERNET/: lan8720.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_exti.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c lwip_sys.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
